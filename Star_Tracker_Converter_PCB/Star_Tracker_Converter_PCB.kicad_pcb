# Repository PeakSat/system-pcbs

## KiCad design Star_Tracker_Converter_PCB/Star_Tracker_Converter_PCB.kicad_pcb

Parts:
C1: 2.2n; C_0402_1005Metric; PartNumber CGA2B2X7R1H222K050BA
C2, C3: 6.8u; C_0805_2012Metric; PartNumber C2012X5R1E685K125AC
C4: 2.2u; C_0402_1005Metric; PartNumber GRM188R60J474KA01D
C5, C6, C7, C9, C10, C11: 22uF; C_0805_2012Metric; PartNumber C0402C104K4RACTU
C8: 100n; C_0402_1005Metric; PartNumber C0402C104K4RACTU
J1: Η1; ESQ-126-39-x-D; PartNumber ESQ-126-39-x-D
J2: Η2; ESQ-126-39-x-D; PartNumber ESQ-126-39-x-D
J4: 504050-0491; 5040500491; Mouser Part Number 538-504050-0491
L1: 2.2u; ASPI-0504-100M-T; PartNumber ASPI-0520LR-2R2M-T2
L2: 0u; L_0805_2012Metric; PartNumber 782853200
R1: 2.2k; R_0603_1608Metric; PartNumber CR0603-JW-222ELF
R2: 18.2k; R_0402_1005Metric; PartNumber CRCW040218K2FKED
R3: 100k; R_0402_1005Metric; PartNumber CR0402-FX-1003GLF
R4: 26.7k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder; PartNumber ERA-2ARB2672X
R5: 4.87k; R_0402_1005Metric; PartNumber CRCW04024K87FKEDC
R6, R7: 0; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TP2: 5V2; TestPoint_Plated_Hole_D2.0mm
TP3: GND; TestPoint_Plated_Hole_D2.0mm
TP4: Vbat; TestPoint_Plated_Hole_D2.0mm
U1: TPS62913; Texas_VQFN-10-HR_2x2_Pitch0.5mm; PartNumber TPS62913

Connections:
3V3_D: J2.10
5V2_STR: C8.1, C9.1, C10.1, C11.1, J4.1, J4.2, L2.2, R3.2, R4.1, TP2.1
5V_PANELS: J1.47, R7.1
/P5V_RF_PG: R3.1, U1.5 (PG)
BUS_SCL: J1.43
BUS_SDA: J1.41
CAN_A+: J1.3
CAN_A-: J1.1
CAN_B+: J2.3
CAN_B-: J2.1
EPS_VBAT: C1.1, C2.1, C3.1, J2.45, J2.46, R6.1, TP4.1, U1.6 (VIN)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C10.2, C11.2, J1.27, J1.28, J1.31, J1.32, J1.39, J1.40, J1.42, J2.29, J2.30, J2.32, J2.39, J2.40, J2.41, J2.42, J2.43, J2.44, J4.3, J4.4, R2.2, R5.2, TP3.1, U1.4 (PGND), U1.7 (PSNS)
GNSS_PPS: J1.14
JTCK-SWCLK: J2.8
JTDO-SWOTRACE: J2.6
JTMS-SWDIO: J2.7
MCU_NRSTD: J2.9
unnamed: R1.1, R6.2, R7.2
unnamed: R1.2, U1.1 (EN/SYNC)
unnamed: C8.2, R4.2, R5.1, U1.9 (FB)
unnamed: C4.1, U1.8 (NR/SS)
unnamed: R2.1, U1.10 (S-CONF)
unnamed: L1.1, U1.2 (SW)
unnamed: C5.1, C6.1, C7.1, L1.2, L2.1, U1.3 (VO)

Notes on the sheet:
OBC UART RX
ADCS CAN-
COMMS_UART_TX
EPS GPIO
EPS 5V ADM
ADCS 5V
ADCS UART RX In
ADCS RS-422 RX_P
PC104 Connector
ADCS 3V3
EPS 3V3 RED
ADCS BOOT
ADCS UART TX Out
RED UART RX
OBC UART TX
ADCS ENABLE
EPS 3V3 OBC
ADCS RS-422 RX_N
ADCS RS-422 TX_P
TODO: Check R Value
ADCS CAN+
RED UART TX
COMMS_UART_RX
ADCS RS-422 TX_N

Board: 4 copper layers, 90.2 x 95.9 mm, 31 parts (0 on the bottom side), 12 nets.

Other parts of the board:
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_DIN965_Pad

File Star_Tracker_Converter_PCB/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,0402,1,2.2n,
"C10, C11, C5, C6, C7, C9",0805,6,22uF,
"C2, C3",0805,2,6.8u,
C4,0402,1,2.2u,
C8,0402,1,100n,
"H1, H2, H3, H4",MountingHole_3.2mm_M3_DIN965_Pad,4,MountingHole_Pad,
J1,ESQ-126-39-x-D,1,Η1,
J2,ESQ-126-39-x-D,1,Η2,
J4,5040500491,1,504050-0491,
L1,ASPI-0504-100M-T,1,2.2u,
L2,0805,1,0u,
R1,0603,1,2.2k,
R2,0402,1,18.2k,
R3,0402,1,100k,
R4,0402,1,26.7k,
R5,0402,1,4.87k,
"R6, R7",0805,2,0,
U1,Texas_VQFN-10-HR_2x2_Pitch0.5mm,1,TPS62913,

## KiCad design PlusX_Cover/PlusX_Cover.kicad_pcb

Board: 4 copper layers, 82.6 x 170.0 mm, 30 parts (12 on the bottom side), 55 nets.

Parts:
H4, H4#2, H4#3, H4#4: MountingHole_Pad; MountingHole_3.5mm
H5, H6, H7, H8: MountingHole_Pad; MountingHole_2.2mm_M2_DIN965_Pad
J1: T2M-107-01-X-D-SM-DS; SAMTEC_T2M-107-01-X-D-SM-DS
J2, J3: Conn_02x06_Odd_Even; 5040501291
J4: M80-6662622; M808282642
J5, J10: Conn_01x06; 504050-0691_2
J6, J12, J13, J14, J15, J16: Conn_01x02; 5040500291
J7: Conn_01x04; 5040500491
J8, J9: Conn_01x12; 5040501291
J11: Conn_02x05_Odd_Even; M808281042
J17: Conn_02x06_Odd_Even; M808281242
J18: SSM-102-L-SV; PinHeader_1x02_P2.54mm_Vertical_SMD_Pin1Left
R1, R2, R3, R5: PWR263S-35-56R0F; PWR263S3556R0F

Connections:
/28V2_KILL: J7.1, J7.2, R2.3, R5.1
/!ABF_PLACED_0: J1.02, J2.2
/!ABF_PLACED_1: J1.11, J2.11
/!BAT_ENA_HS: J1.04, J2.4
/!SAT_ENA_HS: J1.06, J2.6
/!SEPARATION_1: J1.03, J2.3
/!SEPARATION_2: J1.05, J2.5
/!SEPARATION_3: J1.07, J2.7
/ADCS_DEBUGGER_VREF: J4.18, J8.5
/ADCS_SWCLK: J4.12, J9.12
/ADCS_SWDIO: J4.11, J9.11
/ADCS_UART_TX: J4.3, J9.3
/ATLAS_+: J6.1, J17.11
/ATLAS_-: J6.2, J17.12
/ATLAS_SPI_CS: J5.6, J10.6
/ATLAS_SPI_MISO: J5.3, J10.3
/ATLAS_SPI_MOSI: J5.2, J10.2
/ATLAS_SPI_SCK: J5.5, J10.5
/BAT_CHARGE: J3.1, J3.2, J3.3, J3.4, J11.1, J11.2, J11.3, J11.4
/BAT_ENA_LS_NEG: J1.10, J2.10
/BAT_ENA_LS_POS: J1.08, J2.8, J18.2
/BAT_ENA_LS_RBF: J1.09, J2.9, J18.1
/BP_+: J16.1, J17.1
/BP_-: J16.2, J17.2
/COMMS_3V3_REF: J4.25, J8.11
/COMMS_+: J15.1, J17.3
/COMMS_-: J15.2, J17.4
/COMMS_RST: J4.26, J8.12
/COMMS_SWCLK: J4.23, J8.9
/COMMS_SWD: J4.22, J8.8
/COMMS_UART_RX: J3.9, J4.21
/COMMS_UART_TX: J3.10, J4.20
/CubeControl_+: J14.1, J17.5
/CubeControl_-: J14.2, J17.6
/EPS_UART_RX: J3.11, J11.9
/EPS_UART_TX: J3.12, J11.10
/MCU_SWCLK: J4.2, J9.2
/MCU_SWDIO: J4.1, J9.1
/NRST_ADCS: J4.17, J8.4
/NRST_OBC: J4.7, J9.7
/Nadir_+: J13.1, J17.7
/Nadir_-: J13.2, J17.8
/OBC_DEBUGGER_VREF: J4.8, J9.8
/OBC_UART_TX: J4.13, J8.7
/RF_GND: H5.1, H6.1, H7.1, H8.1
/Sun_+: J12.1, J17.9
/Sun_-: J12.2, J17.10
CAN1+: J4.5, J9.5
CAN1-: J4.6, J9.6
CAN2+: J4.14, J8.1
CAN2-: J4.15, J8.2
EPS VBAT: J4.9, J9.9
GND: J1.01, J1.12, J2.1, J2.12, J3.5, J3.6, J3.7, J3.8, J4.4, J4.10, J4.16, J4.19, J4.24, J5.1, J5.4, J7.3, J7.4, J8.3, J8.6, J8.10, J9.4, J9.10, J10.1, J10.4, J11.5, J11.6, J11.7, J11.8, R1.3, R3.1
unnamed: R1.1, R5.3
unnamed: R2.1, R3.3

File PlusX_Cover/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
J1,SAMTEC_T2M-107-01-X-D-SM-DS,1,T2M-107-01-X-D-SM-DS,
"J10, J5",504050-0691_2,2,Conn_01x06,
J11,M808281042,1,Conn_02x05_Odd_Even,
"J12, J13, J14, J15, J16, J6",5040500291,6,Conn_01x02,
J17,M808281242,1,Conn_02x06_Odd_Even,
J18,PinHeader_1x02_P2.54mm_Vertical_SMD_Pin1Left,1,SSM-102-L-SV,
"J2, J3",5040501291,2,Conn_02x06_Odd_Even,
J4,M808282642,1,M80-6662622,
J7,5040500491,1,Conn_01x04,
"J8, J9",5040501291,2,Conn_01x12,
"R1, R2, R3, R5",PWR263S3556R0F,4,PWR263S-35-56R0F,

## Commit log

2024-11-05 +X Cover: Add internal interface
2024-11-07 +X Cover: Add screw-down ABF connector and initial mechanical layout
2024-11-07 +X Cover: Finalize mechanical layout
2024-11-07 +X Cover: Add GNSS mounting
2024-11-08 +X Cover: Internal connector placement
2024-11-08 +X Cover: Finalize external connector placement
2024-11-08 +X Cover: Add gerbers
2024-11-10 Add Sun and Earth Sensor Panel PCBs
2024-11-10 +X Cover: Add temperature sensor connectors
2024-11-10 +X Cover: Add kill resistors
2024-11-10 Kill resistor fix, step generation, gerbers
2024-11-12 Minor updates + gerbers
2024-11-13 +X Cover: Add RBF pin (optional)
2024-11-25 Add GNSS Antenna cable routing notch
2025-01-08 +X Cover: Rotate STR cutout by -88.5 deg
2025-01-10 Fix +X Cover mechanical interface
2025-01-16 Increase STR cutout diameter to account for large tolerances
2025-01-16 +X Cover: Complete routing and annotations
2025-01-24 Add BOM
2025-03-05 +X PCB: Minor fix
2025-04-02 X Cover: Flight Ready Cosmetics
2025-04-02 Add -Z Cover PCB
2025-04-23 Add Star Tracker VBAT-to-5.2V converter PCB
2025-04-25 Minor fixes
2025-04-25 Add STM32 circuit and 3V3 PSU
2025-05-06 Add Star Tracker Converter PCB production files
2025-05-06 Add Alignment Model Panels
